# U-Boot is still built out of tree for now
# TODO: Include patches to add gizmite support

COMPATIBLE_MACHINE_imx6dl-gizmite = "(.)"
